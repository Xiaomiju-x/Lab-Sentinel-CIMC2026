# Keil uVision project CIMC_GD32_Template.uvprojx, settings and files
target CIMC_GD32_Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.5.0
  cpu: IRAM(0x24000000,0x000D0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00020000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: CIMC_GD32_Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32H7XX
  c misc: --c99
  c include: ..\CMSIS;..\CMSIS\GD\GD32H7xx\Include;..\Library\GD32H7xx_standard_peripheral\Include;..\Library\Utilites;..\HeaderFiles;..\User;..\Function;.\..\FreeRTOS\inc;.\..\FreeRTOS\port;.\..\FreeRTOS\src;.\..\HardWare\USART;.\..\HardWare\FreeRTOS;.\..\HardWare\Lab_Sentinel;.\..\HardWare\LED;..\..\ai_models_c;..\HardWare\CI1302;..\..\lvgl_ui\lvgl-8.3.11\src;..\..\lvgl_ui\lvgl-8.3.11;..\..\lvgl_ui;..\HardWare\SDRAM;..\HardWare\LCD;..\HardWare\Touch;..\HardWare\UI;..\HardWare\Actuator;..\HardWare\Sensors;..\HardWare\Camera;..\HardWare\Relay;..\HardWare\Motor;..\HardWare\Smoke;..\HardWare\Mic;..\HardWare\Network;..\lwip\src\include;..\lwip\contrib\ports\freertos\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xd0000
  memory RVCT10: RAM 0x0 size 0x10000
  group User
    ../User/: main.c systick.c gd32h7xx_it.c
  group HardWare
    ../HardWare/CI1302/: ci1302.c
  group Protocol
    ../HardWare/Network/: ethernetif.c modbus_tcp.c http_client.c
    ../lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../lwip/src/netif/: ethernet.c
    ../lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip/contrib/ports/freertos/: sys_arch.c
  group Function
    ../Function/: Function.c
  group HeaderFiles
    ../HeaderFiles/: HeaderFiles.h
  group CMSIS
    ../CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Library
    ../Library/GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_cau.c gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cpdm.c gd32h7xx_crc.c gd32h7xx_ctc.c gd32h7xx_dac.c gd32h7xx_dbg.c gd32h7xx_dci.c gd32h7xx_dma.c gd32h7xx_edout.c gd32h7xx_efuse.c gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_fac.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_hau.c gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hwsem.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_lpdts.c gd32h7xx_mdio.c gd32h7xx_mdma.c gd32h7xx_misc.c gd32h7xx_ospi.c gd32h7xx_ospim.c gd32h7xx_pmu.c gd32h7xx_rameccmu.c gd32h7xx_rcu.c gd32h7xx_rspdif.c gd32h7xx_rtc.c gd32h7xx_rtdec.c gd32h7xx_sai.c gd32h7xx_sdio.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_tmu.c gd32h7xx_trigsel.c gd32h7xx_trng.c gd32h7xx_usart.c gd32h7xx_vref.c gd32h7xx_wwdgt.c gd32h7xx_enet.c
    ../Library/Utilites/: gd32h759i_eval.c
  group Startup
    ../CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group Readme
    ../01 Readme/: Readme.txt
  group FreeRTOS_Core
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Port
    ../FreeRTOS/port/: heap_4.c port.c
  group HardWare/USART
    ../HardWare/USART/: usart.c
  group HardWare/FreeRTOS
    ../HardWare/FreeRTOS/: app_main.c
  group HardWare/Lab_Sentinel
    ../HardWare/Lab_Sentinel/: lab_sentinel.c furnace_sim.c feature_build.c furnace_ctrl.c spc.c health.c sha256.c batch_record.c
  group HardWare/LED
    ../HardWare/LED/: LED.c
    ../HardWare/LCD/: rgb_lcd.c
  group AI_Models
    ../../ai_models_c/: network.c nn_ops.c ai1_cnn.c ai2_ae.c ai3_transformer.c ai4_fusion.c ai1b_ncm.c ai_selftest.c ai1_crucible.c gas_safety.c ai5_diagnose.c ai_new_models.c ai_ext_models.c ai_nanolm.c ai_llm_cluster.c cimc_spiflash.c flash_provision.c ai_lm_bank.c
  group HardWare/SDRAM
    ../HardWare/SDRAM/: sdram.c
  group HardWare/Touch
    ../HardWare/Touch/: gt911.c
  group HardWare/Actuator
    ../HardWare/Actuator/: actuator.c
  group HardWare/Sensors
    ../HardWare/Sensors/: sensors_i2c.c sht30.c adxl345.c mq135.c
  group HardWare/Camera
    ../HardWare/Camera/: sccb.c ov5640.c
  group HardWare/Relay
    ../HardWare/Relay/: relay.c
  group HardWare/Motor
    ../HardWare/Motor/: motor.c
  group HardWare/Smoke
    ../HardWare/Smoke/: smoke_sensor.c
  group HardWare/Mic
    ../HardWare/Mic/: inmp441.c
  group HardWare/UI
    ../HardWare/UI/: lv_port_disp.c lv_port_indev.c ui_screen.c
  group LVGL/core
    ../../lvgl_ui/lvgl-8.3.11/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL/draw
    ../../lvgl_ui/lvgl-8.3.11/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group LVGL/draw/sw
    ../../lvgl_ui/lvgl-8.3.11/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group LVGL/hal
    ../../lvgl_ui/lvgl-8.3.11/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL/misc
    ../../lvgl_ui/lvgl-8.3.11/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL/widgets
    ../../lvgl_ui/lvgl-8.3.11/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL/font
    ../../lvgl_ui/lvgl-8.3.11/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_montserrat_14.c lv_font_montserrat_20.c lv_font_montserrat_18.c lv_font_montserrat_28.c
  group LVGL/extra
    ../../lvgl_ui/lvgl-8.3.11/src/extra/: lv_extra.c
    ../../lvgl_ui/lvgl-8.3.11/src/extra/layouts/flex/: lv_flex.c
    ../../lvgl_ui/lvgl-8.3.11/src/extra/layouts/grid/: lv_grid.c
    ../../lvgl_ui/lvgl-8.3.11/src/extra/themes/default/: lv_theme_default.c
    ../../lvgl_ui/lvgl-8.3.11/src/extra/widgets/list/: lv_list.c
    ../../lvgl_ui/lvgl-8.3.11/src/extra/widgets/led/: lv_led.c
software components: CMSIS:CORE 5.6.0
